# Keil uVision project TFD_A.uvprojx, settings and files
target TFD_A (6230000::V6.23::ARMCLANG)
  device: STM32H503CBUx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x08000000-0x801FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: TFD_A +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H503xx
  c include: ../Core/Inc;../Drivers/STM32H5xx_HAL_Driver/Inc;../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../Drivers/CMSIS/Include;../ND06AV1C_SDK_1.1.0/nd06av1c_examples;../ND06AV1C_SDK_1.1.0/nd06av1c_device/inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32h503xx.s
  group Application/User/Core
    ../Core/Src/: dts6012m.c sensorAppLogic.c nd06av1c_app.c productToolingInspection.c elevatorSignalMonitor.c PDA_Communication.c rs485.c stmflash.c sensorParaTable.c main.c gpio.c i2c.c icache.c iwdg.c memorymap.c rtc.c usart.c stm32h5xx_it.c stm32h5xx_hal_msp.c toolingtest.c
  group Drivers/STM32H5xx_HAL_Driver
    ../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_cortex.c stm32h5xx_hal_i2c.c stm32h5xx_hal_i2c_ex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal.c stm32h5xx_hal_exti.c stm32h5xx_hal_icache.c stm32h5xx_hal_iwdg.c stm32h5xx_hal_rtc.c stm32h5xx_hal_rtc_ex.c stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h5xx.c
  group ND06AV1C
    ../ND06AV1C_SDK_1.1.0/nd06av1c_examples/: platform.c
    ../ND06AV1C_SDK_1.1.0/nd06av1c_device/src/: nd06av1c_comm.c nd06av1c_data.c nd06av1c_dev.c
software components: CMSIS:CORE 4.3.0
